## boards/none/bbc_micro_based_dev_board/board.yml
```yaml
board:
  name: bbc_micro_based_dev_board
  vendor: none
  socs:
    - name: nrf52833
```
